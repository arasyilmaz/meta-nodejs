require nodejs_8.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=fde91d5c5bbd1e0389623e1ac018d9e8"

SRC_URI[src.md5sum] = "e3bb729fd8cde08db6ae1a8b56db2f44"
SRC_URI[src.sha256sum] = "a1a885add3e511177f05676f0834df710886b68cb559b893169f8674a23adfcf"
