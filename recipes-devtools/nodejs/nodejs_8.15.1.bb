require nodejs_8.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=fde91d5c5bbd1e0389623e1ac018d9e8"

SRC_URI[src.md5sum] = "3bbbe4be473026a930340ae106dcb2b3"
SRC_URI[src.sha256sum] = "413e0086bd3abde2dfdd3a905c061a6188cc0faceb819768a53ca9c6422418b4"
